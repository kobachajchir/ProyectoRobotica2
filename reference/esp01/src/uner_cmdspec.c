#include "uner_cmdspec.h"
#include <string.h>

const UNER_CommandSpec *UNER_FindCommandSpec(const UNER_CommandSpec *table, uint8_t count, uint8_t cmd) {
    if (!table) return 0;
    for (uint8_t i = 0; i < count; ++i) if (table[i].id == cmd) return &table[i];
    return 0;
}

static const UNER_CommandSpec g_table[] = {
    {UNER_CMD_SET_MODE_AP, 0, 0, UNER_SPEC_F_ACK | UNER_SPEC_F_RESP, 100, 0},
    {UNER_CMD_SET_MODE_STA, 0, 0, UNER_SPEC_F_ACK | UNER_SPEC_F_RESP, 300, 0},
    {UNER_CMD_SET_CREDENTIALS, 0, 255, UNER_SPEC_F_ACK | UNER_SPEC_F_RESP, 100, 0},
    {UNER_CMD_CLEAR_CREDENTIALS, 0, 0, UNER_SPEC_F_ACK | UNER_SPEC_F_RESP, 100, 0},
    {UNER_CMD_START_SCAN, 0, 0, UNER_SPEC_F_ACK | UNER_SPEC_F_RESP, 200, 0},
    {UNER_CMD_GET_SCAN_RESULTS, 0, 0, UNER_SPEC_F_RESP, 100, 0},
    {UNER_CMD_REBOOT_ESP, 1, 1, UNER_SPEC_F_ACK | UNER_SPEC_F_MANUAL_ACK, 50, 0},
    {UNER_CMD_FACTORY_RESET, 0, 0, UNER_SPEC_F_ACK | UNER_SPEC_F_RESP, 200, 0},
    {UNER_CMD_STOP_SCAN, 0, 0, UNER_SPEC_F_ACK | UNER_SPEC_F_RESP, 100, 0},
    {UNER_CMD_WIFI_GET_DETAIL, 1, 33, 0, 100, 0},
    {UNER_CMD_GET_STATUS, 0, 0, UNER_SPEC_F_RESP, 100, 0},
    /* len=0 legacy; len=2 request WEB con webAlivePeriodMs U16 LE. len=1 es
     * la response status sobre el mismo command id y el handler la ignora. */
    {UNER_CMD_PING, 0, 2, UNER_SPEC_F_RESP, 50, 0},
    {UNER_CMD_GET_PREFERENCES, 0, 0, UNER_SPEC_F_ACK | UNER_SPEC_F_RESP, 100, 0},
    {UNER_CMD_REQUEST_FIRMWARE, 0, 0, UNER_SPEC_F_ACK | UNER_SPEC_F_RESP, 200, 0},
    {UNER_CMD_SET_ENCODER_FAST, 1, 1, UNER_SPEC_F_ACK | UNER_SPEC_F_RESP, 100, 0},
    {UNER_CMD_GET_CONNECTED_USERS, 0, 0, UNER_SPEC_F_RESP, 100, 0},
    {UNER_CMD_GET_USER_INFO, 1, 1, UNER_SPEC_F_RESP, 100, 0},
    {UNER_CMD_GET_INTERFACES_CONNECTED, 0, 0, UNER_SPEC_F_RESP, 100, 0},
    {UNER_CMD_GET_CREDENTIALS, 0, 0, UNER_SPEC_F_RESP, 100, 0},
    {UNER_CMD_SET_AP_FALLBACK, 1, 1, UNER_SPEC_F_ACK | UNER_SPEC_F_RESP | UNER_SPEC_F_MANUAL_ACK, 1000, 0},
    {UNER_CMD_CONNECT_WIFI, 0, 0, UNER_SPEC_F_ACK | UNER_SPEC_F_RESP, 300, 0},
    {UNER_CMD_DISCONNECT_WIFI, 0, 0, UNER_SPEC_F_ACK | UNER_SPEC_F_RESP, 150, 0},
    {UNER_CMD_SET_AP_CONFIG, 8, 102, UNER_SPEC_F_ACK | UNER_SPEC_F_RESP, 200, 0},
    {UNER_CMD_START_AP, 0, 0, UNER_SPEC_F_ACK | UNER_SPEC_F_RESP, 200, 0},
    {UNER_CMD_STOP_AP, 0, 0, UNER_SPEC_F_ACK | UNER_SPEC_F_RESP, 200, 0},
    {UNER_CMD_GET_CONNECTED_USERS_MODE, 0, 0, UNER_SPEC_F_RESP, 100, 0},
    {UNER_CMD_SET_AUTO_RECONNECT, 1, 1, UNER_SPEC_F_ACK | UNER_SPEC_F_RESP, 100, 0},
    {UNER_CMD_BOOT_COMPLETE, 5, 5, UNER_SPEC_F_EVT, 0, 0},
    {UNER_CMD_NETWORK_IP, 5, 5, UNER_SPEC_F_EVT, 0, 0},
    {UNER_CMD_AUTH_VALIDATE_PIN, 6, 6, UNER_SPEC_F_ACK | UNER_SPEC_F_RESP, 5000, 0},
    {UNER_CMD_GET_CURRENT_SCREEN, 0, 45, 0, 0, 0},
    {UNER_CMD_MENU_ITEM_CLICK, 5, 5, UNER_SPEC_F_ACK | UNER_SPEC_F_RESP, 500, 0},
    {UNER_CMD_TRIGGER_ENCODER_BUTTON, 5, 5, UNER_SPEC_F_ACK | UNER_SPEC_F_RESP, 500, 0},
    {UNER_CMD_TRIGGER_USER_BUTTON, 5, 5, UNER_SPEC_F_ACK | UNER_SPEC_F_RESP, 500, 0},
    {UNER_CMD_REQUEST_SCREEN_PAGE, 5, 5, UNER_SPEC_F_ACK | UNER_SPEC_F_RESP, 500, 0},
    {UNER_CMD_TRIGGER_ENCODER_ROTATE_LEFT, 4, 4, UNER_SPEC_F_ACK | UNER_SPEC_F_RESP, 500, 0},
    {UNER_CMD_TRIGGER_ENCODER_ROTATE_RIGHT, 4, 4, UNER_SPEC_F_ACK | UNER_SPEC_F_RESP, 500, 0},
    {UNER_CMD_BINARY_ASSET_STREAM, 0, 255, UNER_SPEC_F_ACK | UNER_SPEC_F_RESP, 2000, 0},
    {UNER_CMD_GET_CAR_MODE, 0, 1, UNER_SPEC_F_RESP, 500, 0},
    {UNER_CMD_WIFI_CREDENTIALS_WEB_RESULT, 1, 38, UNER_SPEC_F_ACK | UNER_SPEC_F_RESP, 500, 0},
    {UNER_CMD_AUTH_REMOTE_RESULT, 6, 6, UNER_SPEC_F_ACK | UNER_SPEC_F_RESP, 500, 0},
    {UNER_CMD_SET_I2C_POLICY, 1, 1, UNER_SPEC_F_RESP, 500, 0},
    {UNER_CMD_GET_I2C_POLICY, 0, 0, UNER_SPEC_F_RESP, 500, 0},
    {UNER_CMD_GET_MPU_SNAPSHOT, 0, 42, UNER_SPEC_F_RESP, 500, 0},
    {UNER_CMD_SET_MPU_STREAM, 1, 3, UNER_SPEC_F_RESP, 500, 0},
    {UNER_CMD_STOP_MPU_STREAM, 0, 2, UNER_SPEC_F_RESP, 500, 0},
    {UNER_CMD_SET_CAR_MODE, 1, 2, UNER_SPEC_F_RESP, 500, 0},
    {UNER_CMD_GET_BOOT_REPORT, 0, 22, UNER_SPEC_F_RESP, 500, 0},
    {UNER_CMD_WIFI_CREDENTIALS_FLOW, 1, 255, UNER_SPEC_F_RESP, 500, 0},
    {UNER_CMD_AP_CLIENTS_PAGE, 2, 2, UNER_SPEC_F_RESP, 250, 0},
    {UNER_CMD_AP_CLIENT_DISCONNECT, 6, 6, UNER_SPEC_F_RESP, 250, 0},
    {UNER_CMD_GET_EXTENSION_PROFILE, 0, 2, UNER_SPEC_F_RESP, 500, 0},
    {UNER_CMD_SET_EXTENSION_PROFILE, 1, 1, UNER_SPEC_F_RESP, 750, 0},
    {UNER_CMD_REBOOT_INTO_PROFILE, 1, 1, UNER_SPEC_F_ACK, 750, 0},
    {UNER_CMD_GET_AP_FALLBACK, 0, 3, UNER_SPEC_F_RESP, 500, 0},
    {UNER_CMD_GET_IR_EMITTERS, 0, 3, UNER_SPEC_F_RESP, 500, 0},
    {UNER_CMD_SET_IR_EMITTERS, 3, 4, UNER_SPEC_F_RESP, 500, 0},
    {UNER_CMD_GET_MOTION_STATE, 0, 8, UNER_SPEC_F_RESP, 500, 0},
    {UNER_CMD_SET_BALANCE_ENABLED, 1, 8, UNER_SPEC_F_RESP, 500, 0},
    {UNER_CMD_SET_MOTION, 8, 10, UNER_SPEC_F_RESP, 500, 0},
    {UNER_CMD_STOP_MOTION, 1, 8, UNER_SPEC_F_RESP, 500, 0},
    {UNER_CMD_SET_MOTOR_TEST, 8, 10, UNER_SPEC_F_RESP, 500, 0},
    {UNER_CMD_ACK, 1, 2, 0, 0, 0},
    {UNER_CMD_NACK, 1, 2, 0, 0, 0},
    {UNER_EVT_BOOT, 0, 255, UNER_SPEC_F_EVT, 0, 0},
    {UNER_EVT_MODE_CHANGED, 0, 255, UNER_SPEC_F_EVT | UNER_SPEC_F_ACK, 50, 0},
    {UNER_EVT_STA_CONNECTED, 0, 255, UNER_SPEC_F_EVT, 0, 0},
    {UNER_EVT_STA_DISCONNECTED, 0, 255, UNER_SPEC_F_EVT, 0, 0},
    {UNER_EVT_AP_CLIENT_JOIN, 0, 255, UNER_SPEC_F_EVT, 0, 0},
    {UNER_EVT_AP_CLIENT_LEAVE, 0, 255, UNER_SPEC_F_EVT, 0, 0},
    {UNER_EVT_APP_USER_CONNECTED, 0, 255, UNER_SPEC_F_EVT, 0, 0},
    {UNER_EVT_APP_USER_DISCONNECTED, 0, 255, UNER_SPEC_F_EVT, 0, 0},
    {UNER_EVT_CONTROLLER_CONNECTED, 0, 255, UNER_SPEC_F_EVT, 0, 0},
    {UNER_EVT_CONTROLLER_DISCONNECTED, 0, 255, UNER_SPEC_F_EVT, 0, 0},
    {UNER_EVT_USB_CONNECTED, 0, 255, UNER_SPEC_F_EVT, 0, 0},
    {UNER_EVT_USB_DISCONNECTED, 0, 255, UNER_SPEC_F_EVT, 0, 0},
    {UNER_EVT_WEBSERVER_UP, 0, 255, UNER_SPEC_F_EVT, 0, 0},
    {UNER_EVT_WEBSERVER_CLIENT_CONNECTED, 0, 255, UNER_SPEC_F_EVT, 0, 0},
    {UNER_EVT_WEBSERVER_CLIENT_DISCONNECTED, 0, 255, UNER_SPEC_F_EVT, 0, 0},
    {UNER_EVT_LASTWIFI_NOTFOUND, 0, 255, UNER_SPEC_F_EVT | UNER_SPEC_F_ACK, 50, 0},
    {UNER_EVT_APP_GET_MPU_READINGS, 42, 42, UNER_SPEC_F_EVT, 0, 0},
    {UNER_EVT_APP_GET_TCRT_READINGS, 0, 255, UNER_SPEC_F_EVT | UNER_SPEC_F_ACK, 50, 0},
    {UNER_EVT_WIFI_CONNECTED, 0, 255, UNER_SPEC_F_EVT, 0, 0},
    {UNER_EVT_NETWORK_IP, 5, 5, UNER_SPEC_F_EVT, 0, 0},
    {UNER_EVT_BOOT_COMPLETE, 5, 5, UNER_SPEC_F_EVT, 0, 0},
    {UNER_EVT_SCREEN_CHANGED, 5, 255, UNER_SPEC_F_EVT, 0, 0},
    {UNER_EVT_MENU_SELECTION_CHANGED, 5, 255, UNER_SPEC_F_EVT, 0, 0},
    {UNER_EVT_CAR_MODE_CHANGED, 1, 1, UNER_SPEC_F_EVT, 0, 0},
    {UNER_EVT_IR_EMITTERS_CHANGED, 3, 3, UNER_SPEC_F_EVT, 0, 0},
    {UNER_EVT_QT_USB_STATE, 1, 1, UNER_SPEC_F_EVT, 0, 0},
    {UNER_EVT_MCU_BOOT_REPORT, 22, 22, UNER_SPEC_F_EVT, 0, 0},
    {UNER_CMD_ECHO, 4, 4, 0, 0, 0},
};

const UNER_CommandSpec *UNER_DefaultCommandTable(uint8_t *count) {
    if (count) *count = (uint8_t)(sizeof(g_table) / sizeof(g_table[0]));
    return g_table;
}

UNER_CommandSpec *UNER_MutableCommandTable(uint8_t *count) {
    enum { TABLE_COUNT = (int)(sizeof(g_table) / sizeof(g_table[0])) };
    static UNER_CommandSpec runtime_table[TABLE_COUNT];
    static uint8_t initialized = 0;

    if (!initialized) {
        memcpy(runtime_table, g_table, sizeof(g_table));
        initialized = 1;
    }
    if (count) *count = (uint8_t)TABLE_COUNT;
    return runtime_table;
}
